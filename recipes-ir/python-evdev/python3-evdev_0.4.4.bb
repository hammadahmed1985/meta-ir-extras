inherit setuptools3
require python-evdev.inc

