inherit setuptools
require python-evdev.inc

