SRC_URI_append = " file://0001-GPIO-keys-and-leds-for-usb-injector.patch"
FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}_${PV}:"

